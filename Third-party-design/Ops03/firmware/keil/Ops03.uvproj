# Keil uVision project Ops03.uvproj, settings and files
target Target 1 (MCS-51)
  device: SST89C54 SST
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) CLOCK(33000000)
  output: No002 +hex
  c flags: Optimize=8
  group Source Group 1
    ./: Main.C keycodes_Q.h keycodes.h vial.h rgb.h action_code.h
